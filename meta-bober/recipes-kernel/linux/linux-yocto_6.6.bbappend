FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
	file://1wire.cfg \
	file://printk.cfg \
"